# IAR project PvSafety.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: Driver\HAL_Inc; Embos; Driver\CMSIS; User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PvSafety.srec
  ILINK.IlinkOutputFile: PvSafety.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/Ewarm
    Driver/CMSIS/: startup_stm32h743xx.s
  group App/User
    User/: PvSafetyAdc1.c PvSafetyAdc1.h PvSafetyAdc2.c PvSafetyAdc2.h PvSafetyAdc3.c PvSafetyAdc3.h PvSafetyCalc.c PvSafetyCalc.h PvSafetyComm.c PvSafetyHmi.c PvSafetyHmi.h PvSafetyInitPeri.c PvSafetyMain.c PvSafetyMain.h PvSafetyPredef.h
  group Driver
    User/: PvSafetyRtc.c
  group Driver/CMSIS
    Driver/CMSIS/: system_stm32h7xx.c
  group Driver/HAL_Driver
    Driver/HAL_Api/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c
  group Embos
    Embos/: JLINKMEM_Process.c os7m_tlv_r.a OS_Error.c RTOSInit_STM32H7xx.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c
